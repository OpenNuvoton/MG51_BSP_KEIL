# Keil uVision project ADC_Compare.uvproj, settings and files
target RegBased (MCS-51)
  device: N76S003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x3FF) CLOCK(16000000)
  output: ADC_Compare +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source Group 1
    ../: main.c
  group Common
    ../../../../Library/StdDriver/src/: sys.c delay.c adc.c common.c uart.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
