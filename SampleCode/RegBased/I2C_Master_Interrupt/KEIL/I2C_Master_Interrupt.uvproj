# Keil uVision project I2C_Master_Interrupt.uvproj, settings and files
target I2C_Master_Interrupt (MCS-51)
  device: MG51FC9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: I2C_Master_Interrupt +hex
  AfterMake: $KC51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc;..\..\I2C0_Master_Interrupt
  link misc: REMOVEUNUSED
  group Source
    ../: main.c table_data.c
  group Library
    ../../../../Library/StdDriver/src/: uart.c i2c.c delay.c sys.c common.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
