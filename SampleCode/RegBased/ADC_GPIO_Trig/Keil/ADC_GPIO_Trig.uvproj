# Keil uVision project ADC_GPIO_Trig.uvproj, settings and files
target RegBased (MCS-51)
  device: MG51FC9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: ADC_Bandgap_VDD +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source Group 1
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: sys.c uart.c common.c adc.c delay.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
