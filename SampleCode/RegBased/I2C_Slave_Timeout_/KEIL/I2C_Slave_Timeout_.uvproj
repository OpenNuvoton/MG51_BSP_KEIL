# Keil uVision project I2C_Slave_Timeout_.uvproj, settings and files
target I2C_Slave_Timeout_ (MCS-51)
  device: MG51FC9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: I2C_Slave_Timeout_ +hex
  AfterMake: $KC51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: sys.c common.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
