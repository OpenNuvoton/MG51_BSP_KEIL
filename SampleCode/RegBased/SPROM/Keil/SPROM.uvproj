# Keil uVision project SPROM.uvproj, settings and files
target RegBased (MCS-51)
  device: MS51XB9BE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: SPROM +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex 0x0 0x1000 0xFF80 0x80
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source Group 1
    ../: main.c ProtectBit.c SPROM.c
  group Library
    ../../../../Library/StdDriver/src/: sys.c uart.c delay.c common.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
