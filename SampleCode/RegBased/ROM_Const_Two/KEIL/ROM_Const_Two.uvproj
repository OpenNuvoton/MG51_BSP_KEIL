# Keil uVision project ROM_Const_Two.uvproj, settings and files
target ROM_Const_Two (MCS-51)
  device: MG51FC9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: ROM_Const_Two +hex
  AfterMake: $KC51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source
    ../: main.c table_address.c table_data.c
  group Library
    ../../../../Library/StdDriver/src/: sys.c common.c uart.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
