# Keil uVision project Timer2_AutoReload_Capture.uvproj, settings and files
target Timer2_AutoReload_Capture (MCS-51)
  device: MG51FC9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: Timer2_AutoReload_Capture +hex
  AfterMake: $KC51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: sys.c common.c uart.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
