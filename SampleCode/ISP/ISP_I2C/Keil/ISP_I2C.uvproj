# Keil uVision project ISP_I2C.uvproj, settings and files
target RegBased (MCS-51)
  device: MG51FC9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: ISP_I2C +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source Group 1
    ../: ISP_I2C.c ISP_I2C_main_autosize_wdtdis.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
